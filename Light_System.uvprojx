# Keil uVision project Light_System.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adc_test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group programming
    ./Src/: adc.c lcd.c light_control.c lora.c mesh.c pwm.c spi_driver.c systick_delay.c watchdog.c
    ./Inc/: adc.h lcd.h light_control.h lora.h mesh.h pwm.h spi_driver.h systick_delay.h watchdog.h
    ./: main.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
