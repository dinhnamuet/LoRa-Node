# Keil uVision project adc_test.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adc_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c systick_delay.c systick_delay.h lcd_hehe.c lcd_hehe.h adc_nam.c adc_nam.h wdt_nam.h wdt_nam.c lora.c lora.h spi_driver.c spi_driver.h mesh_nam.h mesh_nam.c dht11_nam.c dht11_nam.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
